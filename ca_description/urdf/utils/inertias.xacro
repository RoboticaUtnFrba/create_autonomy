Commit message: Split Xacro utils

File: ca_description/urdf/utils/inertias.xacro (robot description, xacro)
@@ -58,5 +58,3 @@
     </inertial>
   </xacro:macro>
-  <xacro:property name="cm_to_m" value="${1./100.}"/>
-  <xacro:property name="in_to_m" value="0.0254"/>
 </robot>
